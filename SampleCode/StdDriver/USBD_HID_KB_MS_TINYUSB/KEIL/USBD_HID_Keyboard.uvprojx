# Keil uVision project USBD_HID_Keyboard.uvprojx, settings and files
target USBD_HID_Keyboard (6210000::V6.21::ARMCLANG)
  device: M467HJHAN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000,0x80000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: USBD_HID_Keyboard
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: CFG_TUD_ENABLED, CFG_TUSB_MCU = OPT_MCU_M463, TU_BYTE_ORDER = TU_LITTLE_ENDIAN,
  c include: .\;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\m460\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\tinyusb-master\src;..\..\..\..\ThirdParty\tinyusb-master\examples\device\hid_multiple_interface\src;..\..\..\..\ThirdParty\tinyusb-master\src\common;..\..\..\..\ThirdParty\tinyusb-master\hw;..\..\..\..\ThirdParty\tinyusb-master\src\class\hid
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --map --first='startup_M460.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/m460/Source/: system_m460.c
    ../../../../Library/Device/Nuvoton/m460/Source/ARM/: startup_m460.s
  group User
    ../: main.c
    ../../../../ThirdParty/tinyusb-master/src/portable/nuvoton/M463/: dcd_M463.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c sys.c clk.c uart.c gpio.c
  group tinyusb
    ../../../../ThirdParty/tinyusb-master/src/device/: usbd.c usbd_control.c
    ../../../../ThirdParty/tinyusb-master/src/: tusb.c
    ../../../../ThirdParty/tinyusb-master/src/common/: tusb_fifo.c
    ../../../../ThirdParty/tinyusb-master/src/class/hid/: hid_device.c
    ../../../../ThirdParty/tinyusb-master/examples/device/hid_multiple_interface/src/: usb_descriptors.c
